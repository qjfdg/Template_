# Keil uVision project STM32F10x_OS3.uvprojx, settings and files
target OS3 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F10x_OS3
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,TRACE_UART
  c include: ..\APP;..\BSP;..\BSP\inc;..\CMSIS;..\FWlib\inc;..\uC-CPU;..\uC-CPU\ARM-Cortex-M3\RealView;..\uC-LIB;..\uC-LIB\Ports\ARM-Cortex-M3\RealView;..\uCOS-III\Ports;..\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;..\uCOS-III\Source;..\USER
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../USER/: app.c os_app_hooks.c
  group BSP
    ../BSP/: bsp.c bsp_int.c
    ../BSP/src/: bsp_swo.c bsp_led.c bsp_uart.c
  group STM32F10x Library
    ../FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../BSP/: cstartup.s
    ../CMSIS/: system_stm32f10x.c
  group uC/CPU
    ../uC-CPU/: cpu_core.c
    ../uC-CPU/ARM-Cortex-M3/RealView/: cpu_a.asm cpu_c.c
  group uC/LIB
    ../uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group uC/OS-III Source
    ../uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group uC/OS-III Port
    ../uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu_a.s os_cpu_c.c
